# Keil uVision project rf_remote_controller_project.uvprojx, settings and files
target stm32f401rct6 (6240000::V6.24::ARMCLANG)
  device: STM32F401RCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rf_remote_controller_project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group src
    ./: main.c gpio.c rcc.c debug.c timebase.c app.c i2c1.c oled.c font5x7_data.c animation.c
  group inc
    ./: gpio.h rcc.h debug.h timebase.h app.h i2c1.h oled.h font5x7_data.h animation.h
software components: CMSIS:CORE 6.1.1, Device:Startup 2.6.3
